# Keil uVision project motor_health_fw.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: motor_health_fw
  c flags: Optimize=8 SizeSpeed=1
  group Core
    ./: STARTUP.A51 system.h system.c main.c
  group Drivers
    ./: uart.h uart.c gpio.h gpio.c timer.h timer.c adc.h adc.c pwm.h pwm.c uart_rx.h uart_rx.c keypad.h keypad.c
  group Config
    ./: pin_config.h
  group Utils
    ./: filter.h filter.c
  group Application
    ./: fault_manager.h fault_manager.c motor_state.h motor_state.c
  group Middleware
    ./: oled.h oled.c
